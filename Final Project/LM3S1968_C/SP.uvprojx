# Keil uVision project SP.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LM3S1968 Texas Instruments
  pack: Keil.LM3S_DFP.1.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x10000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SP +hex
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c
  group ::Device
    RTE/Device/LM3S1968/: Startup.s
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
